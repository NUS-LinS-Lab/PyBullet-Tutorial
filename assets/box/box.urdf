Commit message: revise the box.urdf

File: assets/box/box.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link boxLink: mass 200 -> 0.2
